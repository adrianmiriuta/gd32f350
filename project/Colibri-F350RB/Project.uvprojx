# Keil uVision project Project.uvprojx, settings and files
target TCL_GD32F350RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: trochili +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c include: ..\..\GD32F3x0_DFP\1.0.0\Device\Include;..\..\GD32F3x0_DFP\1.0.0\Device\Firmware\Peripherals\inc;..\..\gd32mcu\inc;..\..\gd32mcu\inc\arch;..\..\gd32mcu\inc\cpu;..\..\gd32mcu\inc\ipc;D:\Keil_v5\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include;..\..\User;..\..\protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group GD32F350_CMSIS
    ../../GD32F3x0_DFP/1.0.0/Device/Source/: system_gd32f3x0.c
    ../../GD32F3x0_DFP/1.0.0/Device/Source/ARM/: startup_gd32f3x0.s
  group GD32F350_FWLIB
    ../../GD32F3x0_DFP/1.0.0/Device/Firmware/Peripherals/src/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group user/uart
    ../../User/uart/: uart.c uart.h
  group user/platform
    ../../User/platform/: platform.c platform.h
  group user/main
    ../../User/: main.c
  group user/delay
    ../../User/delay/: delay.c delay.h
  group user/spiflash
    ../../User/spiflash/: flash_dev.c flash_dev.h spi.c spi.h
  group user/calendar
    ../../User/calendar/: calendar.c calendar.h
  group user/kv
    ../../User/kv/b_kv/b_kv/src/: b_kv.c
    ../../User/kv/b_kv/b_kv/port/: b_kv_config.h b_kv_port.c b_kv_port.h
    ../../User/kv/b_kv/b_kv/inc/: b_kv.h
  group user/timer
    ../../User/timer/: timer.c timer.h
  group user/led
    ../../User/led/: led.c led.h
  group protocol/b_tp
    ../../protocol/b_tp_stream/b_tp/b_tp_port/: b_tp_config.h b_tp_port.c b_tp_port.h
    ../../protocol/b_tp_stream/b_tp/check/crc16/: crc16.c crc16.h
    ../../protocol/b_tp_stream/b_tp/inc/: b_tp.h
    ../../protocol/b_tp_stream/b_tp/src/: b_tp.c
  group protocol/protocol
    ../../protocol/protocol/: protocol.c protocol.h protocol_handle.c protocol_handle.h
